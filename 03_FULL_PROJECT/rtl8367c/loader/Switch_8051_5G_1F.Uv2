### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0000 // Tools: 'MCS-51'

Group (Flash Driver)
Group (common)
Group (NIC Driver)
Group (lwps)
Group (http)
Group (sal)
Group (lib)
Group (tftp client)
Group (asicdrv)
Group (RTK_API)

File 1,1,<..\src\drivers\SPIFlashDrv.c><SPIFlashDrv.c>
File 1,1,<..\src\drivers\SPIFLashDrv_wrapper.c><SPIFLashDrv_wrapper.c>
File 1,1,<..\src\drivers\SPIFlashViewer.c><SPIFlashViewer.c>
File 2,1,<.\src\utilies.c><utilies.c>
File 2,1,<.\src\init.c><init.c>
File 2,1,<.\src\main.c><main.c>
File 2,1,<..\..\common\lib\uart\putchar.c><putchar.c>
File 2,2,<.\src\L51_BANK.A51><L51_BANK.A51>
File 2,2,<.\src\STARTUP.A51><STARTUP.A51>
File 2,1,<.\src\global_variable.c><global_variable.c>
File 2,1,<.\src\upgrade_tftpc.c><upgrade_tftpc.c>
File 2,1,<.\src\isr.c><isr.c>
File 2,1,<.\src\check_boot.c><check_boot.c>
File 2,2,<..\src\reg_acc.A51><reg_acc.A51>
File 2,1,<.\src\dsr.c><dsr.c>
File 2,1,<.\src\loader_start.c><loader_start.c>
File 2,1,<..\src\runtime_loader_msg.c><runtime_loader_msg.c>
File 2,1,<.\src\user_events.c><user_events.c>
File 2,1,<..\src\api\rtk_switch.c><rtk_switch.c>
File 3,1,<..\src\drivers\nic.c><nic.c>
File 4,1,<..\..\common\src\lwps\eth.c><eth.c>
File 4,1,<..\..\common\src\lwps\etharp.c><etharp.c>
File 4,1,<..\..\common\src\lwps\icmp.c><icmp.c>
File 4,1,<..\..\common\src\lwps\ip.c><ip.c>
File 4,1,<..\..\common\src\lwps\lwps_api.c><lwps_api.c>
File 4,1,<..\..\common\src\lwps\udp.c><udp.c>
File 4,1,<..\..\common\src\lwps\tcp.c><tcp.c>
File 5,1,<..\..\common\src\app\web\httpd.c><httpd.c>
File 5,1,<..\..\common\src\app\web\web_api.c><web_api.c>
File 5,1,<.\src\web\html_api.c><html_api.c>
File 5,1,<.\src\web\web_file.c><web_file.c>
File 5,1,<.\src\web\web_hidden.c><web_hidden.c>
File 5,1,<.\src\web\web_http.c><web_http.c>
File 5,1,<.\src\web\web_image.c><web_image.c>
File 5,1,<.\src\web\web_tftp.c><web_tftp.c>
File 5,1,<.\src\web\web_sys.c><web_sys.c>
File 5,1,<.\src\web\web_menu.c><web_menu.c>
File 5,1,<.\src\web\web_info.c><web_info.c>
File 5,1,<.\src\web\web_index.c><web_index.c>
File 5,1,<.\src\web\web_util.c><web_util.c>
File 6,1,<.\src\sal\salutil.c><salutil.c>
File 6,1,<..\src\sal\salfwug.c><salfwug.c>
File 6,1,<.\src\sal\salsys.c><salsys.c>
File 6,1,<.\src\sal\salflash.c><salflash.c>
File 6,1,<.\src\sal\salnic.c><salnic.c>
File 6,1,<.\src\sal\salvlan.c><salvlan.c>
File 7,1,<..\..\common\lib\mem\mem_lib.c><mem_lib.c>
File 8,1,<..\..\common\src\app\tftp\tftpc.c><tftpc.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv.c><rtl8367c_asicdrv.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv_lut.c><rtl8367c_asicdrv_lut.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv_phy.c><rtl8367c_asicdrv_phy.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv_rma.c><rtl8367c_asicdrv_rma.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv_scheduling.c><rtl8367c_asicdrv_scheduling.c>
File 9,1,<..\src\asicdrv\rtl8367c_asicdrv_inbwctrl.c><rtl8367c_asicdrv_inbwctrl.c>
File 9,1,<.\src\asicdrv\rtl8367c_asicdrv_port.c><rtl8367c_asicdrv_port.c>
File 9,1,<.\src\asicdrv\rtl8367c_asicdrv_mirror.c><rtl8367c_asicdrv_mirror.c>
File 10,1,<..\src\api\rate.c><rate.c>
File 10,1,<.\src\api\port.c><port.c>


Options 1,0,0  // Target 'Target 1'
 Device (DW-8051)
 Vendor (Synopsys)
 Cpu (IRAM(0-0xFF) CLOCK(33000000) MODDP2)
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 DevID ()
 Rgf (REG320.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿDallas\)
 OrgReg (ÿDallas\)
 TgStat=16
 OutDir (.\objects\)
 OutName (image)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\objects\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <..\tools\HEX2BIN_64\HEX2BIN_64.exe objects\image.hex objects\image.bin>
 RunUsr 1 1 <..\tools\gen_image.exe l objects\image.hex images\final.bin>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=123152
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,64,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,192,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 0,0,0,0,0,0,0,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,0,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=17435920
 C51VA=0
 C51MSC ()
 C51DEF (RTK_API_8051 EMBEDDED_SUPPORT FLASH_MODE_DUAL DW8051_CLK_625 FLASH_2M LWS_LOADER   LWS_5G_1F FIBER_PORT_6)
 C51UDF ()
 INCC5 (.\include;..\include;.\include\asicdrv;..\include\rtk_api;..\..\common\include;..\..\common\sal;..\..\common\include\sal;.\include\local;..\include\asicDrv;..\src\web;..\include\rtk_api)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=293
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI (.\image.lin)
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DCore51.DLL)(-pDW8051)(S8051.DLL)()(TP51.DLL)(-p320)
  OPTDBG 48125,-1,()()()()()()()()()() ()()()()
 FLASH1 { 1,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ("" ())
 FLASH4 ()
EndOpt

Options 1,1,0  // Group 'Flash Driver'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=0
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

Options 1,3,0  // Group 'NIC Driver'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=0
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

Options 1,5,0  // Group 'http'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=0
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

Options 1,6,0  // Group 'sal'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=0
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

Options 1,7,0  // Group 'lib'
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=0
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=170
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
EndOpt

Options 1,1,1  // File 'SPIFlashDrv.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=1
 AsmAsm=1
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

Options 1,2,11  // File 'upgrade_tftpc.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=0
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

Options 1,2,13  // File 'check_boot.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=2
 AlwaysBuild=2
 GenAsm=1
 AsmAsm=1
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

Options 1,5,35  // File 'web_tftp.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=0
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

Options 1,6,41  // File 'salutil.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=0
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

Options 1,8,48  // File 'tftpc.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=0
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

