# Keil uVision project Switch_8051_8G_2F.uvproj, settings and files
target Target 1 (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: image +hex
  AfterMake: ..\tools\gen_image.exe l objects\image.hex images\final.bin
  c flags: Optimize=8
  c define: RTK_API_8051 EMBEDDED_SUPPORT FLASH_MODE_DUAL DW8051_CLK_208 FLASH_2M LWS_LOADER   LWS_8G_2F FIBER_PORT_70MB SCAN_MODE_LED
  c include: .\include;..\include;.\include\asicdrv;..\include\rtk_api;..\..\common\include;..\..\common\sal;..\..\common\include\sal;.\include\local;..\include\asicDrv;..\src\web;..\include\rtk_api
  group Flash Driver
    ../src/drivers/: SPIFlashDrv.c SPIFLashDrv_wrapper.c SPIFlashViewer.c
  group common
    ./src/: utilies.c init.c main.c L51_BANK.A51 STARTUP.A51 global_variable.c upgrade_tftpc.c isr.c check_boot.c dsr.c loader_start.c user_events.c
    ../../common/lib/uart/: putchar.c
    ../src/: reg_acc.A51 runtime_loader_msg.c
    ../src/api/: rtk_switch.c
  group NIC Driver
    ../src/drivers/: nic.c
  group lwps
    ../../common/src/lwps/: eth.c etharp.c icmp.c ip.c lwps_api.c udp.c tcp.c
  group http
    ../../common/src/app/web/: httpd.c web_api.c
    ./src/web/: html_api.c web_file.c web_hidden.c web_http.c web_image.c web_tftp.c web_sys.c web_menu.c web_info.c web_index.c web_util.c
  group sal
    ./src/sal/: salutil.c salsys.c salflash.c salnic.c salvlan.c
    ../src/sal/: salfwug.c
  group lib
    ../../common/lib/mem/: mem_lib.c
  group tftp client
    ../../common/src/app/tftp/: tftpc.c
  group asicdrv
    ../src/asicdrv/: rtl8367c_asicdrv.c rtl8367c_asicdrv_lut.c rtl8367c_asicdrv_phy.c rtl8367c_asicdrv_rma.c rtl8367c_asicdrv_scheduling.c rtl8367c_asicdrv_inbwctrl.c
    ./src/asicdrv/: rtl8367c_asicdrv_port.c rtl8367c_asicdrv_mirror.c
  group RTK_API
    ../src/api/: rate.c
    ./src/api/: port.c
