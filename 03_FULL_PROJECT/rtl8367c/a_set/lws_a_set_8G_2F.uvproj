# Keil uVision project lws_a_set_8G_2F.uvproj, settings and files
target Target 1 (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: image +hex
  AfterMake: ..\tools\gen_image.exe r objects\image.hex images\final.bin
  c flags: Optimize=8
  c define: EMBEDDED_SUPPORT RTK_API_LWPS SAL_REPLACE LWS_A_SET EEE_ENABLE FLASH_MODE_DUAL DW8051_CLK_208  FLASH_2M RTL8367C INTERNAL_PRIORITY COMPATIBLE_82l   LWS_8G_2F FIBER_PORT_70MB SCAN_MODE_LED
  c include: .\include;..\include;..\include\asicdrv;..\include\rtk_api;..\..\common\include;..\..\common\sal;..\..\common\include\sal;.\include\local;..\..\common\include\rtk_proto\rrcpv3;..\src\web
  group Flash Driver
    ../src/drivers/: SPIFlashDrv.c SPIFLashDrv_wrapper.c SPIFlashViewer.c
  group common
    ../src/: L51_BANK.A51 STARTUP.A51 utilies_flash.c global_variable.c init.c isr.c main.c utilies.c reg_acc.A51 runtime_loader_msg.c
    ../../common/lib/uart/: putchar.c getchar_nb.c
    ../../common/lib/mem/: mem_lib.c
    ./src/: user_events.c
  group NIC Driver
    ../src/drivers/: nic.c
  group lwps
    ../../common/src/lwps/: eth.c etharp.c icmp.c ip.c lwps_api.c tcp.c udp.c igmp_snooping.c igmp_group_db.c ipv6.c
  group sal
    ../src/sal/: salloop.c salmac.c salnic.c salled.c saltrunk.c salport.c salmib.c salrrcpv1.c saleee.c salsys.c salfwd.c salportmask.c salqos.c salutil.c salvlan.c salflash.c salerror.c salgreeneth.c salgpio.c saligmp.c salstp.c salacl.c salsnmp.c salsyslog.c
  group RTK_API
    ../src/api/: rtk_switch.c l2.c port.c trunk.c stat.c mirror.c rate.c qos.c vlan.c igmp.c leaky.c cpu.c eee.c i2c.c
  group asicdrv
    ../src/asicdrv/: rtl8367c_asicdrv.c rtl8367c_asicdrv_acl.c rtl8367c_asicdrv_cputag.c rtl8367c_asicdrv_dot1x.c rtl8367c_asicdrv_eee.c rtl8367c_asicdrv_green.c rtl8367c_asicdrv_hsb.c rtl8367c_asicdrv_igmp.c rtl8367c_asicdrv_inbwctrl.c rtl8367c_asicdrv_lut.c rtl8367c_asicdrv_meter.c rtl8367c_asicdrv_mib.c rtl8367c_asicdrv_mirror.c rtl8367c_asicdrv_misc.c rtl8367c_asicdrv_phy.c rtl8367c_asicdrv_port.c rtl8367c_asicdrv_portIsolation.c rtl8367c_asicdrv_qos.c rtl8367c_asicdrv_rldp.c rtl8367c_asicdrv_rma.c rtl8367c_asicdrv_scheduling.c rtl8367c_asicdrv_specialCongest.c rtl8367c_asicdrv_storm.c rtl8367c_asicdrv_svlan.c rtl8367c_asicdrv_trunking.c rtl8367c_asicdrv_unknownMulticast.c rtl8367c_asicdrv_vlan.c rtl8367c_asicdrv_gpio.c rtl8367c_asicdrv_i2c.c
  group dhcpc
    ../../common/src/app/dhcpc/: dhcpc.c
  group web
    ../../common/src/app/web/: web_api.c httpd.c base64.c
    ../src/web/: html_api.c html_unauth.c web_cfg.c web_eee.c web_file.c web_fwd.c web_fwug.c web_greeneth.c web_hidden.c web_image.c web_index.c web_info.c web_ip.c web_loop.c web_mac.c web_menu.c web_panel.c web_port.c web_qos.c web_sntp.c web_sys.c web_trunk.c web_user.c web_util.c web_vlan.c web_igmp.c web_snmpsec.c web_syslogsec.c web_syslogbuf.c
  group LIB
    ./: driver_protocol_8G_2F.LIB
  group snmp
    ../../common/src/app/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../common/src/app/snmp/mib/: mib_generic.c mib_glue.c EthernetLike.c RMON.c InterfaceGroup.c BridgeMib.c
  group syslog
    ../../common/src/app/syslog/: syslog.c
